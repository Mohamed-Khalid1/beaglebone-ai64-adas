SUMMARY:append = " (+ USB-C gadget networking)"

IMAGE_INSTALL:append = " usb-gadget-net"
